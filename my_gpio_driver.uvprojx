# Keil uVision project my_gpio_driver.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: my_gpio_driver
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Inc;.\Drivers
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App/Src
    ./Src/: main.c
  group Drivers/Custom
    ./Drivers/: my_gpio.c my_gpio.h my_rcc.h my_rcc.c my_timer.h my_timer.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
